# Keil uVision project USBHostLite.uvproj, settings and files
target LPC17xx_IRAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBHostLite +hex
  c flags: Optim=1
  c define: __IRAM
  c include: .\UsbHost\Include;.;..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source
    ./common/src/: core_cm3.c system_LPC17xx.c
  group Uart
    ./UsbHost/Uart/: usbhost_uart.c usbhost_uart.h
  group Fat
    ./UsbHost/Fat/: usbhost_fat.c usbhost_fat.h
  group MassStorage
    ./UsbHost/MassStorage/: usbhost_ms.c usbhost_ms.h
  group Include
    ./UsbHost/Include/: usbhost_err.h usbhost_inc.h
    ../common/inc/: core_cm3.h LPC17xx.h system_LPC17xx.h
  group Host
    ./UsbHost/Host/: usbhost_lpc17xx.c usbhost_lpc17xx.h
  group Main
    ./UsbHost/Main/: usbhost_main.c
  group Startup
    ./common/src/: startup_LPC17xx.s
  group Read
    ./: ReadMe.txt
target LPC17xx_IFLASH (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: USBHostLite +hex
  c flags: Optim=1
  c include: .\UsbHost\Include;.\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
