# Keil uVision project USBCDC.uvproj, settings and files
target LPC17xx Flash (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source
    ./: usbcore.c usbdesc.c usbhw.c usbuser.c cdcuser.c vcomdemo.c serial.c
  group Startup
    ./common/src/: startup_LPC17xx.s
  group Common
    ./common/src/: core_cm3.c system_LPC17xx.c
  group read
    ./: Abstract.txt
target LPC17xx RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x8000
